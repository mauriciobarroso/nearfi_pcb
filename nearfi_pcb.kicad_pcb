# Repository mauriciobarroso/nearfi_pcb

File README.md:

# NearFi PCB | Proximity Wi-Fi Repeater

## Schematic
[Schematic](schematic.pdf)

## Layout
[Layout](layout.pdf)
## 3D Visualizations

### Interactive BOM
[Interactive BOM](https://mauriciobarroso.github.io/ibom/nearfi_revd.html)

## KiCad design nearfi_pcb.kicad_pcb

Parts:
BZ1: PKMCS0909E; Buzzer_Murata_PKMCS0909E; LCSC C910763
C1: 1u; C_0603_1608Metric; LCSC C15849
C2: 22u; C_0603_1608Metric; LCSC C59461
C3, C4, C7, C10, C11, C12: 100n; C_0603_1608Metric; LCSC C14663
C5: 10u; CP_EIA-3216-18_Kemet-A_Pad1.58x1.35mm_HandSolder; LCSC C7171
C6: 100u; CP_EIA-3528-21_Kemet-B_Pad1.50x2.35mm_HandSolder; LCSC C16133
D1, D4: WS2812B-2020; LED_WS2812B-2020_PLCC4_2.0x2.0mm; LCSC C965555
D2, D3: 1N4148WS; D_SOD-323; LCSC C2128
D5, D8, D9: ESD9B5.0ST5G; D_SOD-923; LCSC C111566
D6: RED_LED; LED_0603_1608Metric; LCSC C2286
H1, H2, H3, H4: Hole; MountingHole_3.2mm_M3_Pad_Via
J1: PWR_CNN; TYPE-C-31-M-17; LCSC C283540
J2: PROG_CNN; PinHeader_2x03_P1.27mm_Vertical_SMD; LCSC C3975186
Q1: MMBT3904; SOT-23; LCSC C20526
R1, R3, R4, R6, R8: 10K; R_0603_1608Metric; LCSC C25804
R2, R10: 1K; R_0603_1608Metric; LCSC C21190
R5: 107K; R_0603_1608Metric; LCSC C227542
R7: 5.1K; R_0603_1608Metric; LCSC C23186
R9: 124K; R_0603_1608Metric; LCSC C227568
SW1: SRST_BTN; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS; LCSC C2845270
TP1: SDA; TestPoint_Pad_D1.0mm
TP2: SCL; TestPoint_Pad_D1.0mm
TP3: +5V; TestPoint_Pad_D1.0mm
TP4: +3V3; TestPoint_Pad_D1.0mm
U2: TLV1117-33; SOT-223-3_TabPin2; LCSC C37359
U3: AT24CS02-STUM; SOT-23-5; LCSC C2060969
U4: TPL5010; SOT-23-6; LCSC C473912
U5: ESP32-S3-MINI-1; LCSC C3013941

Connections:
+3.3V: C2.1, C3.2, C4.1, C6.1, C7.2, C10.2, C11.2, D1.4 (VDD), D3.2 (A), D4.4 (VDD), J2.2, R3.1, R4.1, R6.1, R7.1, R8.1, TP4.1, U2.2 (VO), U3.4 (VCC), U4.1 (VDD), U5.3 (3V3)
+5V: BZ1.1 (+), C5.1, D3.1 (K), J1.A9 (VBUS), J1.B9 (VBUS), R10.1, TP3.1, U2.3 (VI)
/BOOT_I: J2.6, U5.4 (GPIO0/BOOT)
/BUZZER_S: R2.2, U5.5 (GPIO1/TOUCH1/ADC1_CH0)
/DONE_S: U4.4 (DONE), U5.38 (MTMS/GPIO42)
/HRST_I: C1.2, D2.1 (K), J2.1, R3.2, U5.45 (EN)
/I2C_SCL_S: D9.2 (A2), R8.2, TP2.1, U3.1 (SCL), U5.36 (MTDO/GPIO40/CLK_OUT2)
/I2C_SDA_S: D8.1 (A1), R4.2, TP1.1, U3.3 (SDA), U5.35 (MTCK/GPIO39/CLK_OUT3/SUBSPICS1)
/SRST_S: C12.1, D5.1 (A1), R6.2, SW1.2, U5.34 (GPIO38/FSPIWP/SUBSPIWP)
/UART_RX_I: J2.5, U5.40 (U0RXD/GPIO44/CLK_OUT2)
/UART_TX_O: J2.3, U5.39 (U0TXD/GPIO43/CLK_OUT1)
/WAKE_S: U4.5 (WAKE), U5.37 (MTDI/GPIO41/CLK_OUT1)
/WS2812B_S: D1.3 (DIN), U5.18 (GPIO14/TOUCH14/ADC2_CH3/FSPIWP/FSPIDQS/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)
unnamed: BZ1.2 (-), Q1.3 (C), R10.2
unnamed: D1.1 (DOUT), D4.3 (DIN)
unnamed: D2.2 (A), U4.6 (~RST)
unnamed: D6.2 (A), R7.2
unnamed: Q1.1 (B), R2.1
unnamed: R1.1, U3.5 (WP)
unnamed: R5.1, R9.1, U4.3 (DELAY/M_RST)

Notes on the sheet:
Buzzer
Decoupling capacitors
ESP32-S3
RGB LED
Programming connector
USB connector
Non-volatile memory
C5 and C6 should be tantalum capacitors
Mounting holes
Software reset button
Time interval 10 min
External WDT
Power supply

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
Board: 4 copper layers, 45.6 x 45.6 mm, 49 parts (0 on the bottom side), 21 nets.

Other parts of the board:
kibuzzard-6488A00A: G***; kibuzzard-6488A00A
kibuzzard-6488A011: G***; kibuzzard-6488A011
kibuzzard-6488A021: G***; kibuzzard-6488A021
kibuzzard-64889FDD: G***; kibuzzard-64889FDD

## KiCad design bitec_nearfi_pcb.kicad_pcb

Parts:
C1, C6: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 22u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7, C10: 10u; CP_EIA-2012-15_AVX-P_Pad1.30x1.05mm_HandSolder
D1: NeoPixel_THT; LED_D5.0mm-4_RGB
D2: LED_PWR; LED_0805_2012Metric_Castellated
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1: PWR_CONN; USB_Micro-B_Molex_47346-0001
J2: CONN_PROG; PinHeader_1x04_P2.54mm_Vertical
R1: 5.1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R4: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: RESET; SW_SPST_TL3342
SW2: BOOT; SW_SPST_TL3342
U1: ESP32-S2-WROVER
U2: TLV1117-33; SOT-223-3_TabPin2

Connections:
+3V3: C1.1, C5.2, C6.2, C10.1, D1.3, J2.1, R1.2, R3.2, R4.2, U1.2 (3V3), U2.2 (VO)
+5V: C7.1, J1.1 (VBUS), U2.3 (VI)
/RGB: D1.4, U1.39 (IO45)
/RXD: J2.3, U1.38 (RXD0)
/TXD: J2.2, U1.37 (TXD0)
GND: C1.2, C4.1, C5.1, C6.1, C7.2, C10.2, D1.2, D2.1 (K), H1.1, H2.1, H3.1, H4.1, J1.5 (GND), J2.4, SW1.1, SW2.1, U1.1 (GND), U1.26 (GND), U1.42 (GND), U1.43 (GND), U2.1 (GND)
unnamed: C4.2, R4.1, SW1.2, U1.41 (EN)
unnamed: D2.2 (A), R1.1
unnamed: R3.1, U1.21 (IO18)
unnamed: SW2.2, U1.3 (IO00)

Notes on the sheet:
Power supply
Note: - C7 and C10 should be tantalum capacitors
ESP32-S2
RGB LED

Board: 2 copper layers, 45.6 x 45.6 mm, 21 parts (0 on the bottom side), 10 nets.

## Commit log

2021-05-15 Modified .gitignore LICENSE and README.md files
2021-05-15 Added schematic pcb and project files
2021-05-15 Modified PCB
2021-05-15 Changed name files
2021-05-18 Finished version 1
2021-07-29 Edited some details
2021-07-31 Changed components and corrected errors
2021-10-22 Added official Espressif devices library
2021-10-22 Added LCSC parts number and new ESP32-S2-WROOM symbol
2021-10-22 Updated PCB
2021-10-22 Added panelized version
2022-01-10 Updated .gitignore file
2022-01-10 Deleted panelized version
2023-06-13 deleted files for kicad older version
2023-06-13 improved schematic and pcb layout, finished rev D
2023-06-13 improved esp32s3 module +3V3 power trace
2023-06-23 finished rev D
2024-07-22 updated .gitignore
2024-07-22 updated to work with kicad v8
2024-07-22 deleted ibom folder
2024-07-22 added pcb images
2024-07-22 added schematic image
2024-07-23 added schematic and layout pdf files
2024-07-23 deleted schematic image
2024-07-23 updated schematic and layout

Notices in the files:
nearfi_pcb.kicad_pcb:
License: MIT license
